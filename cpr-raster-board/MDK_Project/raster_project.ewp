# IAR project raster_project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\MDK_FWlib\inc; ..\MDK_System\Inc; ..\MDK_User; ..\MDK_APP
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: raster_project.s19
  ILINK.IlinkOutputFile: raster_project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group MDK_APP
    ../MDK_APP/: app_bsp.c app_bsp.h app_timming.c app_timming.h
  group MDK_FWlib/Inc
    ../MDK_FWlib/inc/: stm8s.h stm8s_adc1.h stm8s_adc2.h stm8s_awu.h stm8s_beep.h stm8s_can.h stm8s_clk.h stm8s_exti.h stm8s_flash.h stm8s_gpio.h stm8s_i2c.h stm8s_itc.h stm8s_iwdg.h stm8s_rst.h stm8s_spi.h stm8s_tim1.h stm8s_tim2.h stm8s_tim3.h stm8s_tim4.h stm8s_tim5.h stm8s_tim6.h stm8s_uart1.h stm8s_uart2.h stm8s_uart3.h stm8s_uart4.h stm8s_wwdg.h
  group MDK_FWlib/Scr
    ../MDK_FWlib/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c stm8s_wwdg.c
  group MDK_System/Inc
    ../MDK_System/Inc/: app_general_tim.h app_message.h app_sys.h app_usart.h
  group MDK_System/Scr
    ../MDK_System/Scr/: app_general_tim.c app_message.c app_sys.c app_usart.c
  group MDK_User
    ../MDK_User/: main.c stm8s_conf.h stm8s_it.c stm8s_it.h
